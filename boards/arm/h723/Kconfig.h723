## boards/arm/h723/Kconfig.h723
```kconfig
# Copyright (c) 2023 STMicroelectronics
# SPDX-License-Identifier: Apache-2.0

config BOARD_H723
	select SOC_STM32H723XX
```
